# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPM3HQFDFG Toshiba
  pack: Keil.TXZ3_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LIB\inc;.\USER;.\SYSTEM;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group LIB
    ./LIB/src/: txz_adc.c txz_adc_ch.c txz_adc_dma.c txz_cg.c txz_dma.c txz_dma_ex.c txz_gpio.c txz_hal.c txz_i2c.c txz_t32a.c txz_tspi.c txz_tspi_dma.c txz_uart.c txz_uart_dma.c txz_uart_ex.c
  group BSP
    ./BSP/: bsp.c bsp.h bsp_led.c bsp_led.h bsp_uart.c bsp_uart.h bsp_key.c bsp_key.h bsp_switch.c bsp_switch.h oled_iic.c oled_iic.h oled_font.h oled.c oled.h
  group SYSTEM
    ./SYSTEM/: sys.c sys.h
  group USER
    ./USER/: main.c main.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.3
